# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507_Project (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "C:\ti\mspm0_sdk_2_05_00_05\tools\keil\syscfg.bat "$P" empty.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\ti;..\;..\third_party\CMSIS\Core\Include;..\USER\BSP;..\USER\ICM45686;..\USER\IMU;..\USER\LCD;..\USER\Easy_Menu;..\USER\Key;..\USER\LED;..\USER\Motor;..\USER\Gray;..\USER\PID;..\..\Car
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20200000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: "C:\ti\mspm0_sdk_2_05_00_05\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a"
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c basic_read_reg.c task.c sysctl_init.c
    ./: startup_mspm0g350x_uvision.s
  group USER
    ../USER/BSP/: bsp_iic.c bsp_spi.c
    ../USER/ICM45686/: inv_imu_driver.c inv_imu_transport.c
    ../USER/IMU/: IMU.c
    ../USER/LED/: LED.c
    ../USER/LCD/: LCD.c LCD_Font.c
    ../USER/Easy_Menu/: Easy_Menu.c Easy_Menu_Core.c Easy_Menu_Item.c Easy_Menu_Page.c Easy_Menu_User.c
    ../USER/Key/: Key.c
    ../USER/Motor/: encoder.c motor.c
    ../USER/PID/: pid.c
  group Driverlib
    ../ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c dl_sysctl.c
